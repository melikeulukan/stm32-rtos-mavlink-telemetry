## zephyr_app/boards/st/nucleo_f303ze/board.yml
```yaml
board:
  name: nucleo_f303ze
  full_name: Nucleo F303ZE
  vendor: st
  socs:
    - name: stm32f303xe
```
